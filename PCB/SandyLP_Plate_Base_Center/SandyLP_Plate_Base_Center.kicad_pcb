# Repository jpskenn/SandyLP

File README.md:

# SandyLP（サンディ エルピー）

SandyLP is a 40% keyboard with symmetrical row staggered layout and key height optimization.

Layered PCB will make height differences for each key.
This covers the lack of optimization to physical key layout in two dimensions that only adjust x-y plane.

---

SandyLPは、スイッチの配置を立体的にして高さ方向への最適化を加えた、左右対称ロースタッガード配列の40%キーボードです。  

平面上のキーレイアウトだけでは最適化しきれない部分を、キーの位置に応じてスイッチを配置する高さを変えることで補っています。

前機種の[Sandy](https://github.com/jpskenn/Sandy)を元に、ロープロファイルスイッチへの対応と、レイアウトの調整をおこなっています。

名前の由来は、立体的、つまり3Dという意味を込めたSandyに、ロープロファイル版（＝ Low Profile version）を意味するLPを追加しました。

## 特徴

### 左右対称のキーレイアウト  

[Jones](https://github.com/jpskenn/Jones)と同様の、2行目と3行目にずれのない、左右対称なシンメトリカル ロースタッガードのレイアウトです。  

一般的なロースタッガードなレイアウトとの共通性を残しつつ、左右対称で打鍵しやすくなるよう、[SemiErgo Layout](https://github.com/mtei/SemiErgo_Layout)に準ずるキーマッピングで使用することを念頭に設計しています。  
Z行の左右端にシフトキーを用意していないので、スペースキーを「Space and Shift」として使うと便利です。

`T`と`Y`、`G`と`H`の間の2キーは実際のところそれほど使用することはありませんが、ここに2キー分の間隔があいてることで左右の手を広げることになり、肩を疲れにくくします。  
また、この間隔がゼロになると左右の親指が当たって動きを妨げてしまうため、あえて間隔をあけています。

このレイアウトは、市販の各種キーキャップセットのうち「Base Kit」と呼ばれる基本的なキットですべてを埋めることができます。また、104キーの英語キーキャップセットでも十分実用が可能です。

詳しくは、[Keyboard Layout Editor: SandyLP](https://www.keyboard-layout-editor.com/#/gists/29f5da09ffa69ab85efa4c68b556282b)を参照してください。

### キースイッチを立体的に配置  

前機種の[Sandy](https://github.com/jpskenn/Sandy)と同じく、キースイッチを3段階の高さで立体的に配置しています。  
平面上ではキーを配置できる範囲が限られるため、一部のキーはどうしても指が届きにくくなってしまいます。例えば、[Jones](https://github.com/jpskenn/Jones)では左右対称のレイアウトを採用することで右手小指の`P`や`Back Space`、`Enter`などは打鍵しやすくなりましたが、右手人差し指の`Y`は少し遠く感じられました。  
このような箇所について、キーの配置を高くすることで打鍵しやすさを向上させています。  

キーの高さはLow（基準高＝0mm）, Middle（3.6mm）, High（8.7mm）の3段階で、以下のように配置されます。  

### キーボード自体が低い（薄い）  

ロープロファイルの`Choc V2`スイッチを採用することでキーボード自体が低くなりました。  
前機種のSandyからは7.2mm（※1）低くなり、パームレストを使わずとも、手首をあまり反らさないポジションで打鍵できます。

※1 ボトムプレートから1段目のスイッチ軸の天面までの高さを比較。なお、Sandyは理論上あと0.8mm低くすることが可能です。

### RP2040を採用した構成により、多機能なファームウェアを使用可能

RP2040を採用した構成により、キーボード向けのファームウェアを格納するには十分すぎるほどのフラッシュ容量を得ることができました。  
エンコーダーやオーディオ、その他各種機能の同時有効化や、多数のレイヤーを使用するなど、多機能なファームウェアを使用可能です。

### Remap、Vialによるキー割り当ての変更  

初期書き込み済みのファームウェアは[Remap](https://remap-keys.app/)に対応しており、プログラミング等の知識がなくても、キーマッピングやロータリーエンコーダへの割り当てを、ブラウザ等を使って簡単に変更できます。  

また、Vial対応のファームウェアに書き換えて使用することもできます。

### オプション機能  

- ロータリーエンコーダ
- インジケータLED
- オーディオ

## ビルドガイド

- [SandyLP（DN0010）](/docs/BuildGuide_DN0010.md)（最新版）

## SNSタグ

[#SandyLP_kbd](https://twitter.com/search?q=%23SandyLP_kbd)

## ギャラリー

w/ NuPhy nSA BOW

w/ Signature Plastics DSS Solarized Dark

w/ Keyreative KAT Space Cadet, DN0011 Switch Plate

## 参考事例

- [TreK Lagoon](https://zenn.dev/digitarhythm/articles/a559b4b19fc959) by おおやけハジメ さん
- [Sparrow62](https://github.com/74th/sparrow62-buildguide/blob/master/sparrow62_v2.md) by 74th さん

## 開発経緯

以前開発した[Sandy](https://github.com/jpskenn/Sandy)を1年半ほど使い続け、日常使いの長期ロードテストとして十分な情報を得ることができました。  
その情報を元にSandyのアップデート版（Sandy DN0040）の開発をおこない、あとは基板製造の発注をするだけの段階となっていましたが、Sandyの課題のひとつとして挙げていた手首の負荷軽減、つまりキーボードを低くする変更を取り込まなかったことが様々な思いの中でほんのりと燻り続けていました。

ちょうどその頃、Choc V2スイッチのラインナップにたいへん素性の良い静音タイプが追加されました。そして、自分が普段好んで使っているMX用のキーキャップをそのスイッチと組み合わせて使えそうだという情報が得られたことから、ロープロファイルのスイッチを使用したSandyの派生版開発に踏み切りました。  

使用するスイッチの変更で、派生版の開発においてそこそこの量の設計変更が見込まれることから、ついでにキーレイアウトも変更することにしました。  
これまでに開発した`Jones`や`Sandy`では、頒布・販売することを念頭に想定するユーザーの最大公約数的なところへ歩み寄ったレイアウトにしていましたが、今回は自分の使用スタイルを最優先し、自分にとって不要な数字行や左右端のシフトキーなどを取り除いて、少し尖ったレイアウトに変更しました。

こうして、SandyLPが誕生することとなりました。

## KiCad design PCB/SandyLP_Base/SandyLP_Base.kicad_pcb

Parts:
C1, C2: 10u; C_0805_2012Metric; LCSC C15850
C3, C4, C5, C6, C7, C8, C9, C10, C11, C12, C14, C15, C18, C19, C20, C21: 100n; C_0402_1005Metric; LCSC C1525
C13, C16, C17: 2.2uF; C_0402_1005Metric; LCSC C307418
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34: D; D_SOD-123_Emphasized_Direction_Line_Reference_on_bottom; LCSC C81598
D99: PRTR5V0U2X; SOT-143; LCSC C78442
F1: Fuse; Fuse_0603_1608Metric; LCSC C187605
H_btm_1, H_btm_2, H_btm_3, H_btm_4, H_btm_5, H_btm_6, H_btm_7, H_btm_8, H_btm_9, H_btm_10, H_btm_11: MountingHole; MountingHole_2.2mm_M2_No_Cu
H_mid_1, H_mid_2, H_mid_3, H_mid_4, H_mid_5, H_mid_6, H_mid_7, H_mid_8, H_mid_9, H_mid_10, H_mid_11, H_mid_12, H_mid_13, H_mid_14, H_mid_15, H_mid_16, H_mid_17, H_mid_18: MountingHole; MountingHole_1.8-2.2mm_M2_Pad_minimal
J1: Conn_01x10_Pin; PinHeader_1x10_P1.00mm_Vertical
J2: Conn_01x01_Pin; TestPoint_THTPad_D1.0mm_Drill0.5mm
J3: Conn_02x02_Odd_Even; PinHeader_2x02_P2.00mm_Vertical_2pair
J7: USB_C_Receptacle_USB2.0; USB_C_Receptacle_HRO_TYPE-C-31-M-12; LCSC C165948
J8: Conn_01x03; PinHeader_1x03_P2.54mm_Vertical_All_circle
JP1: SolderJumper_2_Open; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
L1, L2, L3, L4, L5, L6: SK6812MINI-E; YS-SK6812MINI-E_middle_hole_with_small_pad
LOGO1: Logo_Base; SandyLP_logo_LP40_w60
LS1: Speaker; Buzzer_Murata_PKMCS0909E; LCSC-Reserve C910763
Q1: BSS138; SOT-23; LCSC C78284
R1, R2: 5.1k; R_0402_1005Metric; LCSC C25905
R5, R8, R10, R11, R12, R13: 1k; R_0402_1005Metric; LCSC C11702
R6, R7: 27; R_0402_1005Metric; LCSC C25100
R9: 10k; R_0402_1005Metric; LCSC C25744
SD1: Schottky diode; D_SOD-123; LCSC C8598
STLED1: LED_GREEN; LED_0201_0603Metric_Pad0.64x0.40mm_HandSolder
SW1: BOOT; SW_SPST_TL3342; LCSC-Reserve C2886897
SW3: BOOT_ALT; SW_SPST_PTS810; LCSC-Reserve C116501
SW_/1: SW_Push; Kailh_socket_ChocV2
SW_;1: SW_Push; Kailh_socket_ChocV2
SW_<1: SW_Push; Kailh_socket_ChocV2
SW_>1: SW_Push; Kailh_socket_ChocV2
SW_A1: SW_Push; Kailh_socket_ChocV2
SW_B1: SW_Push; Kailh_socket_ChocV2
SW_C1: SW_Push; Kailh_socket_ChocV2
SW_CTL1: SW_Push; Kailh_socket_ChocV2
SW_D1: SW_Push; Kailh_socket_ChocV2
SW_E1: SW_Push; Kailh_socket_ChocV2
SW_ENT1: SW_Push; Kailh_socket_ChocV2
SW_F1: SW_Push; Kailh_socket_ChocV2
SW_I1: SW_Push; Kailh_socket_ChocV2
SW_J1: SW_Push; Kailh_socket_ChocV2
SW_K1: SW_Push; Kailh_socket_ChocV2
SW_L1: SW_Push; Kailh_socket_ChocV2
SW_LALTu1: SW_Push; Kailh_socket_ChocV2
SW_LSPC1: SW_Push; Kailh_socket_ChocV2
SW_LWIN1: SW_Push; Kailh_socket_ChocV2
SW_M1: SW_Push; Kailh_socket_ChocV2
SW_N1: SW_Push; Kailh_socket_ChocV2
SW_O1: SW_Push; Kailh_socket_ChocV2
SW_R5CNT_C1: RotaryEncoder_Switch; ChocV2_AND_RotaryEncoder_Alps_EC11K-Switch_Vertical_H20mm_N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
SW_R5CNT_L1, SW_R5CNT_R1: SW_Push; Kailh_socket_ChocV2
SW_RALT1: SW_Push; Kailh_socket_ChocV2
SW_RSPC1: SW_Push; Kailh_socket_ChocV2
SW_RWIN1: SW_Push; Kailh_socket_ChocV2
SW_S1: SW_Push; Kailh_socket_ChocV2
SW_V1: SW_Push; Kailh_socket_ChocV2
SW_W1: SW_Push; Kailh_socket_ChocV2
SW_X1: SW_Push; Kailh_socket_ChocV2
SW_Z1: SW_Push; Kailh_socket_ChocV2
T_C0, T_C1, T_C2, T_C3, T_C4, T_C5, T_C6: Conn_01x01; TestPoint_THTPad_D2.0mm_Drill1.0mm
T_R0, T_R1, T_R2, T_R3, T_R4, T_R5, T_R6, T_R7: Conn_01x01; TestPoint_THTPad_D2.0mm_Drill1.0mm
U1: NCP1117-3.3_SOT223; SOT-223-3_TabPin2; LCSC C347222
U2: RP2040; RP2040-QFN-56; LCSC C2040
U3: W25Q128JVPIQ; WSON-8-1EP_6x5mm_P1.27mm_EP3.4x4.3mm; LCSC C190862
Y1: 12MHz; Resonator_SMD_Murata_CSTxExxV-3Pin_3.0x1.1mm; MFR.Part # CSTNE12M0G550000R0; LCSC C341520

Connections:
+1V1: C3.1, C4.1, C16.1, U2.23 (DVDD), U2.45 (VREG_VOUT), U2.50 (DVDD)
+3V3: C2.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C17.1, JP1.1 (A), Q1.1 (G), R9.1, R11.2, U1.2 (VO), U2.1 (IOVDD), U2.10 (IOVDD), U2.22 (IOVDD), U2.33 (IOVDD), U2.42 (IOVDD), U2.43 (ADC_AVDD), U2.44 (VREG_IN), U2.48 (USB_VDD), U2.49 (IOVDD), U3.8 (VCC)
+5V: C1.1, C14.2, C15.2, C18.2, C19.2, C20.2, C21.2, L1.1 (VDD), L2.1 (VDD), L3.1 (VDD), L4.1 (VDD), L5.1 (VDD), L6.1 (VDD), R12.2, SD1.1 (K), U1.3 (VI)
Audio1: D34.1 (K), R13.2, U2.29 (GPIO18)
D+: D99.2 (I/O1), J7.A6 (D+), J7.B6 (D+), R6.2
D-: D99.3 (I/O2), J7.A7 (D-), J7.B7 (D-), R7.2
GPIO12: J2.1, U2.15 (GPIO12)
GPIO20: J1.1, U2.31 (GPIO20)
GPIO21: J1.2, U2.32 (GPIO21)
GPIO22: J1.3, U2.34 (GPIO22)
GPIO23: J1.4, U2.35 (GPIO23)
GPIO24: J1.5, U2.36 (GPIO24)
GPIO25: J1.6, U2.37 (GPIO25)
GPIO26: J1.7, U2.38 (GPIO26_ADC0)
GPIO27: J1.8, U2.39 (GPIO27_ADC1)
GPIO28: J1.9, U2.40 (GPIO28_ADC2)
GPIO29: J1.10, U2.41 (GPIO29_ADC3)
LED_D_3V3: Q1.2 (S), R11.1, U2.30 (GPIO19)
LED_D_5V: L1.4 (DIN), Q1.3 (D), R12.1
LED_D_5V_CONNECTION: L3.2 (DOUT), L4.4 (DIN)
unnamed: D1.2 (A), SW_W1.2
unnamed: D2.2 (A), SW_E1.2
unnamed: D3.2 (A), SW_I1.2
unnamed: D4.2 (A), SW_O1.2
unnamed: D5.2 (A), SW_CTL1.2
unnamed: D6.2 (A), SW_A1.2
unnamed: D7.2 (A), SW_S1.2
unnamed: D8.2 (A), SW_D1.2
unnamed: D9.2 (A), SW_F1.2
unnamed: D10.2 (A), SW_J1.2
unnamed: D11.2 (A), SW_K1.2
unnamed: D12.2 (A), SW_L1.2
unnamed: D13.2 (A), SW_;1.2
unnamed: D14.2 (A), SW_ENT1.2
unnamed: D15.2 (A), SW_Z1.2
unnamed: D16.2 (A), SW_X1.2
unnamed: D17.2 (A), SW_C1.2
unnamed: D18.2 (A), SW_V1.2
unnamed: D19.2 (A), SW_B1.2
unnamed: D20.2 (A), SW_N1.2
unnamed: D21.2 (A), SW_M1.2
unnamed: D22.2 (A), SW_<1.2
unnamed: D23.2 (A), SW_>1.2
unnamed: D24.2 (A), SW_/1.2
unnamed: D25.2 (A), SW_LWIN1.2
unnamed: D26.2 (A), SW_LALTu1.2
unnamed: D27.2 (A), SW_LSPC1.2
unnamed: D28.2 (A), SW_R5CNT_L1.2
unnamed: D29.2 (A), SW_R5CNT_C1.S2
unnamed: D30.2 (A), SW_R5CNT_R1.2
unnamed: D31.2 (A), SW_RSPC1.2
unnamed: D32.2 (A), SW_RALT1.2
unnamed: D33.2 (A), SW_RWIN1.2
unnamed: J7.A5 (CC1), R1.1
unnamed: J7.B5 (CC2), R2.1
unnamed: JP1.2 (B), R5.2
unnamed: L1.2 (DOUT), L2.4 (DIN)
unnamed: L2.2 (DOUT), L3.4 (DIN)
unnamed: L4.2 (DOUT), L5.4 (DIN)
unnamed: L5.2 (DOUT), L6.4 (DIN)
unnamed: LS1.1, R13.1
unnamed: R8.1, Y1.3
unnamed: F1.2, SD1.2 (A)
unnamed: R5.1, STLED1.2 (A)
unnamed: R7.1, U2.46 (USB_DM)
unnamed: R6.1, U2.47 (USB_DP)
unnamed: U2.20 (XIN), Y1.1
unnamed: R8.2, U2.21 (XOUT)
QSPI_SCLK: U2.52 (QSPI_SCLK), U3.6 (CLK)
QSPI_SD0: U2.53 (QSPI_SD0), U3.5 (DI(IO0))
QSPI_SD1: U2.55 (QSPI_SD1), U3.2 (DO(IO1))
QSPI_SD2: U2.54 (QSPI_SD2), U3.3 (IO2)
QSPI_SD3: U2.51 (QSPI_SD3), U3.7 (IO3)
QSPI_SS: R9.2, R10.2, U2.56 (QSPI_SS), U3.1 (~CS)
RE_Base1_A: SW_R5CNT_C1.A, U2.14 (GPIO11)
RE_Base1_B: SW_R5CNT_C1.B, U2.13 (GPIO10)
SWCLK: J8.1, U2.24 (SWCLK)
SWD: J8.3, U2.25 (SWD)
USB_BOOT: J3.3, R10.1, SW1.1, SW3.2
VBUS: D99.4 (VCC), F1.1, J7.A4 (VBUS), J7.A9 (VBUS), J7.B4 (VBUS), J7.B9 (VBUS)
col1: SW_C1.1, SW_D1.1, SW_E1.1, SW_LALTu1.1, SW_LWIN1.1, SW_S1.1, SW_V1.1, SW_W1.1, T_C1.1, U2.6 (GPIO4)
col5: SW_<1.1, SW_I1.1, SW_K1.1, SW_L1.1, SW_M1.1, SW_O1.1, SW_RALT1.1, SW_RWIN1.1, T_C5.1, U2.4 (GPIO2)
row3: D25.1 (K), D27.1 (K), D29.1 (K), D30.1 (K), D32.1 (K), T_R3.1, U2.16 (GPIO13)
row7: D26.1 (K), D28.1 (K), D31.1 (K), D33.1 (K), T_R7.1, U2.17 (GPIO14)

Notes on the sheet:
SCREWS to Mid
SCREWS to Bottom Plate
Speaker
No SW connected to row2, col4
Connection diagram (Virtual)
44PIN
USB
LOGO
45PIN
Reserved pins
Base to Top via Middle
Base to Middle
LED
ERCチェックで、 TopとMidのラベルが見つからないのはOK。 （別プロジェクトでやる）
KEY MATRIX, Base plate
Max keys = 10 rows * 8 cols = 80 Physical keys = 15 + 14 + 14 + 15 + 13 = 71 5-way nav = 5 Remap/VIA virtual key assign for 2 encoders = 2 * 2 = 4 Balance = 0 (!)

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
Board: 2 copper layers, 275.5 x 80.3 mm, 168 parts (123 on the bottom side), 97 nets.

## KiCad design PCB/SandyLP_Middle_Isolated_Area/SandyLP_Middle_Isolated_Area.kicad_pcb

Board: 2 copper layers, 42.3 x 20.8 mm, 16 parts (11 on the bottom side), 7 nets.

Parts:
Cutout1: 60_Outline; SandyLP_outline_Mid_Isolated_Area_gentle_corner
D1, D2, D3, D4: D; D_SOD-123_Emphasized_Direction_Line
H1, H2, H3, H4: MountingHole; MountingHole_2.2mm_M2_Pad_minimal
SW_BS1: SW_Push; Kailh_socket_ChocV2_for_Reverse_no_hole
SW_P1: SW_Push; Kailh_socket_ChocV2_small_#2pad_for_Reverse_no_hole
SW_Q1: SW_Push; Kailh_socket_ChocV2_for_Reverse
SW_TAB1: SW_Push; Kailh_socket_ChocV2_for_Reverse_narrow_#2pad
T_C0/C6: Conn_01x01; TestPoint_THTPad_D2.0mm_Drill1.0mm
T_R0, T_R4: Conn_01x01; TestPoint_THTPad_D2.0mm_Drill1.0mm

Connections:
Mid_col0/6: H1.1, SW_BS1.1, SW_P1.1, SW_Q1.1, SW_TAB1.1, T_C0/C6.1
Mid_row0: D1.1 (K), D3.1 (K), H3.1, T_R0.1
Mid_row4: D2.1 (K), D4.1 (K), H2.1, T_R4.1
unnamed: D1.2 (A), SW_TAB1.2
unnamed: D2.2 (A), SW_Q1.2
unnamed: D3.2 (A), SW_P1.2
unnamed: D4.2 (A), SW_BS1.2

## KiCad design PCB/SandyLP_Middle/SandyLP_Middle.kicad_pcb

Board: 2 copper layers, 113.1 x 58.7 mm, 37 parts (21 on the bottom side), 17 nets.

Parts:
Cutout1: 60_Outline; SandyLP_outline_Mid
D3, D4, D7, D9, D11, D12, D13: D; D_SOD-123_Emphasized_Direction_Line
EXT_MC2, EXT_MC3, EXT_MC4: Conn_01x01; TestPoint_THTPad_D2.0mm_Drill1.0mm
EXT_MR0, EXT_MR2, EXT_MR4, EXT_MR5, EXT_MR6: Conn_01x01; TestPoint_THTPad_D2.0mm_Drill1.0mm
H1, H2, H3, H4, H5, H6, H7, H8: MountingHole; MountingHole_1.8-2.2mm_M2_Pad_minimal
H_top_1, H_top_3, H_top_4, H_top_5: MountingHole; MountingHole_1.8-2.2mm_M2_Pad_minimal
H_top_2, H_top_6: MountingHole; MountingHole_2.2mm_M2_Pad_minimal
SW_G1: SW_Push; Kailh_socket_ChocV2_small_#2pad
SW_H1: SW_Push; Kailh_socket_ChocV2
SW_R1, SW_R4CNT_L1: SW_Push; Kailh_socket_ChocV2_small_#2pad
SW_R4CNT_C1, SW_R4CNT_R1: SW_Push; Kailh_socket_ChocV2_narrow_#2pad
SW_U1: SW_Push; Kailh_socket_ChocV2

Connections:
GND: H4.1, H_top_5.1
Mid_col2: EXT_MC2.1, H3.1, SW_G1.1, SW_R1.1, SW_R4CNT_L1.1, SW_U1.1
Mid_col3: EXT_MC3.1, H_top_2.1, SW_H1.1, SW_R4CNT_C1.1
Mid_col4: EXT_MC4.1, H_top_6.1, SW_R4CNT_R1.1
Mid_row0: D3.1 (K), EXT_MR0.1, H1.1, H_top_1.1
Mid_row1: H6.1, H_top_4.1
Mid_row2: D12.1 (K), D13.1 (K), EXT_MR2.1, H8.1
Mid_row4: D4.1 (K), EXT_MR4.1, H2.1, H_top_3.1
Mid_row5: D7.1 (K), D9.1 (K), EXT_MR5.1, H5.1
Mid_row6: D11.1 (K), EXT_MR6.1, H7.1
unnamed: D3.2 (A), SW_R1.2
unnamed: D4.2 (A), SW_U1.2
unnamed: D7.2 (A), SW_G1.2
unnamed: D9.2 (A), SW_H1.2
unnamed: D11.2 (A), SW_R4CNT_L1.2
unnamed: D12.2 (A), SW_R4CNT_C1.2
unnamed: D13.2 (A), SW_R4CNT_R1.2

## KiCad design PCB/SandyLP_Top/SandyLP_Top.kicad_pcb

Board: 2 copper layers, 74.9 x 39.4 mm, 23 parts (11 on the bottom side), 11 nets.

Parts:
D1, D2, D3, D4, D5, D6: D; D_SOD-123_Emphasized_Direction_Line
EXT_TC3, EXT_TC4: Conn_01x01; TestPoint_THTPad_D2.0mm_Drill1.0mm
EXT_TR0, EXT_TR1, EXT_TR4: Conn_01x01; TestPoint_THTPad_D2.0mm_Drill1.0mm
H1, H2, H3, H4, H5, H6: MountingHole; MountingHole_1.8-2.2mm_M2_Pad_minimal
SW_'1: SW_Push; Kailh_socket_ChocV2
SW_;1: SW_Push; Kailh_socket_ChocV2_small_#2pad
SW_T1: SW_Push; Kailh_socket_ChocV2
SW_Y1: SW_Push; Kailh_socket_ChocV2
SW_[1: SW_Push; Kailh_socket_ChocV2_small_#2pad
SW_]1: SW_Push; Kailh_socket_ChocV2

Connections:
unnamed: D1.2 (A), SW_[1.2
unnamed: D2.2 (A), SW_]1.2
unnamed: D3.2 (A), SW_Y1.2
unnamed: D4.2 (A), SW_T1.2
unnamed: D5.2 (A), SW_;1.2
unnamed: D6.2 (A), SW_'1.2
Top_col3: EXT_TC3.1, H2.1, SW_;1.1, SW_[1.1, SW_]1.1
Top_col4: EXT_TC4.1, H6.1, SW_'1.1, SW_T1.1, SW_Y1.1
Top_row0: D1.1 (K), D3.1 (K), EXT_TR0.1, H1.1
Top_row1: D5.1 (K), D6.1 (K), EXT_TR1.1, H4.1
Top_row4: D2.1 (K), D4.1 (K), EXT_TR4.1, H3.1

## Commit log

2024-09-13 migrate from Sandy repo.
2024-09-13 基板外形をLP版に変更。不要ファイル削除。
2024-09-13 Topを仮配線。Midとの接続も一応確定
2024-09-13 不要ファイル削除
2024-09-13 ピン調整
2024-09-13 プロジェクト名に沿って、名前を変更。
2024-09-13 スイッチの位置ずれ修正。ネジ位置調整。
2024-09-13 とりあえずフットプリントを配置。左右孤立部などは考え中。
2024-09-14 ネジ位置調整
2024-09-14 Mid孤立部分をリバーシブルで作成
2024-09-14 回路図編集：基板間接続、ネジ、フットプリント指定
2024-09-14 Base外形作成。ネジ配置。
2024-09-14 不要なものを整理。
2024-09-14 ネジ位置変更
2024-09-14 基板外形を調整。ネジ位置変更。ゾーンのクリアランス調整。
2024-09-14 サーマルスポーク幅調整
2024-09-14 WIP パーツ配置
2024-09-14 New Logo
2024-09-14 add "art board"
2024-09-14 ロゴ更新。パーツ配置調整中。
2024-09-14 USBコネクタ周りの配線に合わせて、Mid孤立部分のネジへのピン割り当てを変更。
2024-09-15 配線完了。ビア打ちまだ。
2024-09-15 基板外形を調整
2024-09-15 外形調整。スイッチ穴配置。
2024-09-15 スイッチ穴配置。
2024-09-15 ロゴ追加
2024-09-15 ロゴ修正
2024-09-15 ChocスイッチのFシルク削除
2024-09-15 後からねじ止めするアイコン（＝ドライバー）に変更
2024-09-15 外形のコーナーを緩く。LOGOの設定修正。
2024-09-15 外形のコーナーを緩く。
2024-09-15 スイッチ穴をPTHに変更。
2024-09-16 LED窓の形状を丸に変更し、位置を調整。
2024-09-16 ビア打ち
2024-09-16 ネジ穴にアイコンを追加
2024-09-16 ネジ穴のアイコンを更新
2024-09-16 基板厚を指定。STEPファイル出力設定。
2024-09-16 ロータリーエンコーダの穴サイズを縦に拡大
2024-09-16 ロータリーエンコーダの配置方向を縦から横に変更。
    ロータリーエンコーダの端子がプレートに当たるのを回避するようにスイッチプレートの縦を広げると、Base用スイッチプレートの枠が細くなりすぎて強度が足りなくなるため、ロータリーエンコーダの配置方向を変更指定対応した。
2024-09-16 不要シルク削除
2024-09-16 ボトムプレートとの接続アイコンを修正
2024-09-16 大きいサイズを書き出し
2024-09-16 ボトムプレート作成
2024-09-16 Top基板裏面のパーツ干渉を回避するため、穴を開けた。
2024-09-16 オプションが無料になったのでJLCのマーキングを削除。その他シルク位置調整。
2024-09-16 Top基板裏面のパーツ干渉を回避するための穴が、前面から見えにくいように位置調整。
2024-09-16 太めのバージョンを追加
2024-09-16 底面ロゴのサイズを大きく
2024-09-17 initial
2024-09-17 書き始め
2024-09-17 add KLE link
2024-09-17 ロゴを大きく
2024-09-17 QRコードの位置調整
2024-09-17 製造用ファイル出力
2024-09-18 パーツなど追記
2024-09-18 基板Mid中央くらいまで
2024-09-18 バリエーションを追加
2024-09-18 基板Mid左右あたりまで
2024-09-18 マトリクスの未使用部分のメモを追加
2024-09-18 Base基板まで
2024-09-19 スイッチプレートはこれから
2024-09-19 ゴムシート貼り付け
2024-09-19 ロゴ更新
2024-09-19 基板Baseにスローガンを書いているので、こちらは削除。
2024-09-19 ロゴ調整
2024-09-20 だいたい完成まで
2024-09-20 カスタマイズガイドまで
2024-09-20 初期ファームウェアあたりまで
2024-09-20 VIA用jsonと、その元ネタのKLE。
2024-09-20 Mid左右プレートは判別可能だった
2024-09-20 cherry pick
2024-09-20 内容を充実
2024-09-21 シルク追加。ロゴのフットプリント指定を修正。
2024-09-21 各種部品の個数追記など
2024-09-22 番号なくても問題ないので削除
2024-09-22 用語統一など
2024-09-23 強調表示
2024-09-24 説明追加。フォーマット
2024-09-26 章立て変更。説明追加。
2024-09-29 100*100mmサイズで製造する3分割プレートの中央部
2024-09-29 45度回転させる前のファイルは10x10cmに治らないので削除
2024-09-29 100*100mmサイズで製造する3分割プレートの左右部
2024-10-01 取り付け位置
2024-10-01 ネジの表記を変更
2024-10-01 写真必要な箇所など洗い出し
2024-10-01 組み合わせる手順を変更
2024-10-02 組み合わせる手順
2024-10-02 折り畳み廃止
2024-10-02 細かなところを追記
2024-10-02 フォーマット
2024-10-02 区切り線無くても問題なし
2024-10-02 目次再生成
2024-10-02 写真追加。数量調整。
2024-10-02 Remap
2024-10-03 写真追加
2024-10-03 電源LED。フォーマット
2024-10-03 説明を簡潔に
2024-10-03 はんだ作業、ネジ止めさぎょうごとに作業を分け、章立てを再構成
2024-10-03 目次を1段階深く
2024-10-04 全般的な内容に変更
2024-10-04 何を確認するかわかりやすく
2024-10-04 章タイトル変更
2024-10-04 手順をわかりやすく
2024-10-04 3mmのゴムシートの方が厚く、耐震ジェルでボトムプレートを接着できなかったため、ボツ。
2024-10-04 画像リンクの修正など
2024-10-04 スピーカー取り付け方向をわかりやすく
2024-10-04 ネジ等のアイコンは全般的な説明なので、章の頭へ移動。
2024-10-04 貼り付けなどわかりやすく
2024-10-04 フォーマット。細かな言い回し。
2024-10-04 ユーザーズマニュアル追記
2024-10-04 写真変更
2024-10-04 写真追加・変更
2024-10-04 LEDの表示状態について追記
2024-10-05 写真変更、ファームウェア書き換えを追記。
2024-10-05 大した内容がないので、項目削除。
2024-10-05 レイヤーの初期設定を調整
2024-10-05 説明追加
2024-10-06 レイヤー移動関連追記
2024-10-06 キーの表記を統一
2024-10-06 ファームウェア配置
2024-10-06 ファームウェア等へリンク
2024-10-06 不要リンク削除
2024-10-06 写真追加。説明調整。
2024-10-06 テンキーにマイナス入れ忘れ→再ビルド
2024-10-06 各部更新
2024-10-06 表記を調整。
2024-10-06 画像リンク修正
2024-10-06 フォーマット。微調整。
2024-10-06 微調整。
2024-10-06 画像の一部に関係のない図形が表示されていたので差し替え。
2024-10-06 注意喚起を追加
2024-10-06 難しいアピール
2024-10-06 LED間へゴムシートを貼り付けなくても特に問題ないので、画像変更。
2024-10-06 プラ板を追加
2024-10-06 レイアウトの変更予定はないので、Remap／VIA用ファイルの名前から開発番号を除去。
2024-10-06 ファイル名変更に合わせて変更。
2024-10-06 レイアウトに追記
2024-10-07 DFはEEPROMへ書き込む仕様に変更したため、記述削除
2024-10-08 ファームウェア機能について追記
2024-10-08 再ビルド
2024-10-16 QMKのkeyboard_nameと混同していたのを修正
2024-10-19 ギャラリー、写真追加
2024-10-19 フォーマット調整
2024-10-19 言葉がすんなり頭に入るような表記に変更。
2024-10-19 わかりやすく
2024-10-20 キーキャップの選び方をわかりやすく。組み合わせ結果を追加。
2024-10-29 ヒントの表記をGithubのアラート表記に変更
2024-10-29 Revert "ヒントの表記をGithubのアラート表記に変更"
    This reverts commit 52fab7aa1da7ca3f3f7fa421fb6c2d8caec13257.
2024-10-29 インデント箇所にGithubのアラート表記できないので、元に戻す。
2024-11-12 名称間違いを修正
2024-11-29 プレートは3分割にするため、1枚版を削除。
2024-11-29 ネジ穴の位置を修正。
    ネジ穴の位置が移動したので、シルク位置も調整。
    GNDのVIAも位置調整。
2024-11-30 issue セカンダリスピーカーを削除 #25
    - スピーカー関連削除
    - 未使用となったGPIO12をテストポイントとしてアクセス可能に
    - 付近の配線、GNDベタ調整
2024-11-30 削除済みライブラリの設定を削除
    2572ce33344e119e6e2473be618736b9877bf1ac
    ffcb92e4bd719dc83005bf5ec57ce6f44203b766
    43e8af02b79423429bf58ee78a68bb7a6a2996a0
2024-11-30 LEDの位置を変更
    周りの配線を調整
2024-11-30 作業ファイル削除
2024-11-30 LED窓の位置を変更
2024-11-30 LED窓バリエーション。縦線
2024-11-30 issue BOOTSELスイッチを両対応 #28
    PTS810スイッチを隣に並べた。
    RESETスイッチは削除して、ピンヘッダに出した。
    LEDはサイズを変更。
2024-11-30 ロータリーエンコーダとダイオードが近すぎるので、少し離した。
2024-11-30 Mid-ISOの中央ネジがソケットのパッドに近すぎるので、少し上へ移動
    USBのD+、D-なども合わせて調整。
2024-11-30 ネジとソケットのパッドか近くはんだ付けが心配なため、パッドを少し小さくする。
2024-11-30 MCUまわりのCを近づける
2024-11-30 USB配線まわりを、ネジ穴、ナット、使用する工具（十字レンチなど）から離す
2024-12-01 LEDのパスコンを基板端から離して調整
2024-12-01 不要コメント削除
2024-12-01 基板Base左右角のネジ穴が近すぎるため、少し離した。
    ナットとスペーサーを締める工具（十字レンチ）が入らないのを回避。
    組み合わせるボトムプレートも、ネジ穴を同じ位置に変更。
2024-12-01 基板原点を元の位置に戻した
2024-12-01 C1,C2バーツ変更に伴う、チップサイズ変更。
    JLCPCBのSMTAで、ExtendedからBasicのパーツに変更。
2024-12-01 Top基板 ゴムシート貼り付け指標
2024-12-01 Mid基板 ゴムシート貼り付け指標
2024-12-01 Mid-ISO基板 ゴムシート貼り付け指標
2024-12-01 Base基板 ゴムシート貼り付け指標
2024-12-01 Base基板 LED光線漏れ対応
2024-12-02 新規 DN0010をコピーしてDN0020に変えただけ
2024-12-02 長いスペーサー廃止
2024-12-02 基板の名前間違いを修正
2024-12-02 注意事項の思い
2024-12-02 プレートBase LとR ゴムシート貼り付け指標
    リバーシブルをやめ、LとRをそれぞれ製造するように変更。
    この変更に伴い`LR`は削除。
2024-12-02 プレートBase Center ゴムシート貼り付け指標
